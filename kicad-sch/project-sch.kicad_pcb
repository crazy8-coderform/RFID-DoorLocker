# Repository crazy8-coderform/RFID-DoorLocker

File README.md:

# RFID-DoorLocker
based on arduino uno development board for my first cash in

## KiCad design kicad-sch/project-sch.kicad_pcb

Parts:
D1: LED; LED_D3.0mm
SW1: SW_DPST_x2; SW_PUSH_6mm
U1: PinSocket_1x07_P1.27mm_Vertical
U2: PinHeader_1x06_P1.27mm_Vertical
U3: PinHeader_1x10_P1.27mm_Vertical
U4, U6: PinHeader_1x08_P1.27mm_Vertical
U5: PinHeader_1x04_P1.27mm_Vertical
U7: PinHeader_1x03_P1.27mm_Vertical

Connections:
+3.3V: U1.3 (3.3v), U5.2 (VCC), U6.8 (3.3V), U7.2 (VCC)
/5: U4.3 (5), U6.7 (RST)
/9: U3.9, U7.3 (DATA)
/10: U3.8 (10), U6.1 (SDA)
/11: U3.7 (11), U6.3 (MOSI)
/12: U3.6 (12), U6.4 (MISO)
/13: U3.5 (13), U6.2 (SCK)
/A4: U2.5 (A4), U5.3 (SDA)
/A5: U2.6 (A5), U5.4 (SCL)
GND: D1.1 (K), SW1.1 (A), U1.5 (GND), U1.6 (GND), U3.4 (GND), U5.1 (GND), U6.6 (GND), U7.1 (GND)
unnamed: D1.2 (A), U4.6 (2)
unnamed: SW1.2 (B), U4.5 (3)

Notes on the sheet:
LCD1602-SPI
RFID-RC522
SERVE
主控部分

Board: 2 copper layers, 76.2 x 55.9 mm, 9 parts (0 on the bottom side), 12 nets.
